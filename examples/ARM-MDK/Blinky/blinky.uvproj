# Keil uVision project blinky.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC812M101 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x3FFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: blinky
  c flags: Optim=1
  c include: ../../../com
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group src
    ./src/: startup_LPC8xx.s system_LPC8xx.c
  group edl8f
    ../../../com/: EDL8F.c EDL8F_GPIO.c EDL8F_WKT.c EventManager.c SystemManager.c
    ./src/: blinky.c
